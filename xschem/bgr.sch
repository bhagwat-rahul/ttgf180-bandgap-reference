v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} -20 0 0 0 {name=VAPWR lab=VAPWR}
C {iopin.sym} 0 40 0 0 {name=VGND lab=VGND}
C {opin.sym} 100 -10 0 0 {name=VBGR lab=VBGR}
