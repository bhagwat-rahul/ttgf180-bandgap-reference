** sch_path: xschem/bgr.sch
**.subckt bgr VAPWR VGND VBGR
*.iopin VAPWR
*.iopin VGND
*.opin VBGR
Rdummy VAPWR VGND 1G m=1
Vdummy VBGR VGND DC 1.2
**.ends
.end
