v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
T {5T OTA to act as a CMOS error amp for forcing BJT collector-sense nodes equal in BGR} -460 -100 0 0 0.4 0.4 {}
