v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
T {5T OTA to act as a CMOS error amp for forcing BJT collector-sense nodes equal in BGR} -460 -100 0 0 0.4 0.4 {}
C {iopin.sym} -290 210 0 0 {name=VAPWR lab=VAPWR}
C {iopin.sym} -110 200 0 0 {name=VGND lab=VGND}
C {ipin.sym} -250 30 0 0 {name=VIN_P lab=VIN_P}
C {ipin.sym} -210 80 0 0 {name=VIN_N lab=VIN_N}
C {ipin.sym} -150 90 0 0 {name=VBIAS lab=VBIAS}
C {opin.sym} -80 40 0 0 {name=VOUT lab=VOUT}
